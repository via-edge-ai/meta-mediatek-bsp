FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-HACK-mediatek-weston-add-clear-mode-flow-for-hotplug.patch \
            file://0001-Support-waylandsink-to-set-position.patch \
            file://0001-Waive-set-position-to-0-0-for-QT-compatible.patch \
            "

