FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-Support-long-press-power-button-to-shut-down.patch \
            file://0003-Stop-restart-after-shutdown.patch \
            "

