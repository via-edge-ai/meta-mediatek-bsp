# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-security/optee/optee-client.inc

SRCREV = "06e1b32f6a7028e039c625b07cfc25fda0c17d53"
COMPATIBLE_MACHINE = "mt*"
