require optee-os-mtk.inc
