# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-security/optee/optee-examples.inc

SRCREV = "9a755dcf4d8ef6117af59dfd1b1a82315cee58ca"
COMPATIBLE_MACHINE = "mt*"
