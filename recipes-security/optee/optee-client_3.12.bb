# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-security/optee/optee-client.inc

SRCREV = "347144b79964233e718347e3f0fbe89ab5be46ae"
COMPATIBLE_MACHINE = "mt*"
