FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

PV = "3.8.0+git${SRCPV}"
SRCREV = "be4fa2e36f717f03ca46e574aa66f697a897d090"
