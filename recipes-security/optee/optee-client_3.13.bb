# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-security/optee/optee-client.inc

SRCREV = "7c9c423d00e96bf51debd5fe10fd70dce83be5cc"
COMPATIBLE_MACHINE = "mt*"
