# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require mdp-prebuilt.inc
require mdpd.inc

LIC_FILES_CHKSUM = "file://../LICENSE;md5=6fcd7dfec853b4eca3b44877b51c0943"
S = "${WORKDIR}/git/mdpd"
B = "${WORKDIR}/git/mdpd/${SOC_FAMILY}"
