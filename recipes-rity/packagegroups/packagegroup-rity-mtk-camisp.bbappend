RDEPENDS:${PN}:remove = " \
	mtk-camisp-prebuilts \
"

RDEPENDS:${PN}:append = " \
	mtk-camisp-mw \
	mtk-camisp-libcamera \
	libutils \
	libcutils \
	libsync \
"
